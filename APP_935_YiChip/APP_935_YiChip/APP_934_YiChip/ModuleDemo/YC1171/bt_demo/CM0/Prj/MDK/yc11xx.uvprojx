# Keil uVision project yc11xx.uvprojx, settings and files
target blueware (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: yc11xx +hex
  AfterMake: fromelf.exe --text -a -c --output=@L_asm.txt "!L"
  AfterMake: "Objects/tool/c.bat"
  c flags: Optim=2 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99 --gnu -DARM_MATH_CM0 -DFIXED_POINT
  c include: ..\..\..\..\..\..\Librarier\device;..\..\yc_hci;..\..\..\..\..\..\Librarier\drivers\uart;..\..\..\..\..\..\Librarier\drivers\gpio;..\..\..\..\..\..\Librarier\drivers\debug;..\..\..\..\..\..\Librarier\drivers\bt;..\..\..\..\..\..\Librarier\drivers\timer;..\..\..\..\..\..\Librarier\drivers\systick;..\..\..\..\..\..\Librarier\drivers\hal;..\..\..\..\..\..\Librarier\drivers\wdt;..\..\..\..\..\..\Librarier\drivers\qspi;..\..\application;..\..\blueware\include;..\..\blueware\lib_include;..\..\hal;..\..\profile;..\..\update;..\..\..\..\..\..\Librarier\drivers\usb\scpu_usb_CDC_Device_Demo;..\..\..\..\..\..\Librarier\drivers\usb\libraries\harward_Der;..\..\..\..\..\..\Librarier\drivers\usb\libraries\SCPU_USB_Device_Library\core;..\..\..\..\..\..\Librarier\drivers\usb\libraries\SCPU_USB_Device_Library\class\HID;..\..\..\..\..\..\Librarier\drivers\usb\libraries\SCPU_USB_Device_Library\class\CDC
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Objects\yc11xx.sct
  group application
    ../../application/: main.c
  group startup
    ../../../../../../Librarier/startup/: startup.s
  group driver
    ../../../../../../Librarier/device/: yc11xx.c nvic.c
    ../../../../../../Librarier/drivers/uart/: yc11xx_uart.c
    ../../../../../../Librarier/drivers/bt/: yc11xx_bt.c
    ../../../../../../Librarier/drivers/debug/: yc_debug.c
    ../../../../../../Librarier/drivers/hal/: yc_drv_common.c
    ../../../../../../Librarier/drivers/gpio/: yc11xx_gpio.c
    ../../../../../../Librarier/drivers/queue/: yc_queue.c
    ../../../../../../Librarier/drivers/systick/: yc11xx_systick.c
    ../../../../../../Librarier/drivers/timer/: yc11xx_timer.c yc_timer.c
    ../../../../../../Librarier/drivers/wdt/: yc11xx_wdt.c
    ../../../../../../Librarier/drivers/qspi/: yc11xx_qspi.c
  group usb
    ../../../../../../Librarier/drivers/usb/scpu_usb_CDC_Device_Demo/: usb_main.c usbd_desc.c usbd_usr.c
    ../../../../../../Librarier/drivers/usb/libraries/harward_Der/: usb_core.c Usb_dcd.c Usb_dcd_init.c
    ../../../../../../Librarier/drivers/usb/libraries/SCPU_USB_Device_Library/core/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../../../../../../Librarier/drivers/usb/libraries/SCPU_USB_Device_Library/class/CDC/: usbd_cdc_core.c
    ../../../../../../Librarier/drivers/usb/libraries/SCPU_USB_Device_Library/class/HID/: usbd_hid_keyboard_core.c
